<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SW_DRV_FOR_4500.ewp</path>
  </project>
  <batchBuild />
</workspace>
